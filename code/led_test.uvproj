# Keil uVision project led_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C51 NXP (founded by Philips)
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: led_test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 led.c
